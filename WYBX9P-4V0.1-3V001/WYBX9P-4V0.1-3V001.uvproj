# Keil uVision project WYBX9P-4V0.1-3V001.uvproj, settings and files
target WYBX9P-4V0.1-3V001 (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F105VC STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x803FFFF) CLOCK(25000000) CPUTYPE("Cortex-M3")
  output: WYBX9P-4V0.1-3V001 +hex
  c flags: Optim=1 uC99=1 v6Lang=1 v6LangP=1
  c define: STM32F10X_CL, USE_STDPERIPH_DRIVER
  c include: .\FWlib\inc;.\user;.\user\usart;.\user\CAN;.\user\System_Init;.\user\Charger_Control;.\user\PCF8563;.\user\DWIN_LCD;.\user\24C0X;.\user\TF;.\user\Flash;.\user\IIC;.\user\SD
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group User
    ./user/: main.c stm32f10x_it.c g_uiNtcTable_Tempeature.c
    ./user/usart/: usart.c
    ./user/CAN/: CAN.c
    ./user/System_Init/: System_Init.c
    ./user/Charger_Control/: Charger_Control.c
    ./user/DWIN_LCD/: DWIN_LCD.c
    ./user/PCF8563/: PCF8563.c
    ./user/24C0X/: 24C0X.c
    ./user/TF/: TF.c
    ./user/Flash/: Flash.c
    ./user/IIC/: IIC.c
    ./user/SD/: SD.c
  group StdPeriph_Drive
    ./FWlib/SRC/: misc.c stm32f10x_rcc.c stm32f10x_gpio.c stm32f10x_usart.c stm32f10x_can.c stm32f10x_tim.c stm32f10x_flash.c stm32f10x_iwdg.c stm32f10x_spi.c
  group CMSIS
    ./user/: core_cm3.c system_stm32f10x.c
  group Startup
    ./startup/: startup_stm32f10x_cl.s
  group 开发记录
    ./: 开发记录.txt
